# Allegro board DSI86_ASICEVM_REV3.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DSI_A0P: length 41.7
  TOP w0.076: U1.H3 36.55,45.15 36.55,44.77 36.44,44.66 36.44,44.27
  TOP w0.127: J4.33 12.17,51.37 12.28,51.48 15.49,51.48 19.08,47.89 19.88,47.89 20.52,48.53 21.18,48.53 21.51,48.2 21.51,47.54 20.87,46.9 20.87,46.1 21.43,45.53 22.23,45.53 22.88,46.18 23.46,46.18 23.86,45.77 23.86,45.19 23.22,44.55 23.22,43.75 26.66,40.31 27.43,40.31 28,40.88 28,41.85 28.41,42.26 28.99,42.26 29.4,41.85 29.4,40.88 29.96,40.31 33.8,40.31 35.53,42.05 35.53,42.88 36.44,43.78 36.44,44.27
  vias: v1(12.18,51.37)
DSI_A1N: length 42.4
  TOP w0.076: U1.J4 36.8,44.38
  TOP w0.127: J4.27 12.15,48.87 12.27,48.75 13.58,48.75 13.76,48.57 13.87,48.57 13.9,48.59 14,48.59 14.08,48.52 14.08,48.41 14.05,48.39 14.05,48.28 14.12,48.21 14.23,48.21 14.26,48.23 14.36,48.23 14.43,48.16 14.43,48.06 14.41,48.03 14.41,47.92 14.48,47.85 14.59,47.85 14.61,47.88 14.72,47.88 14.79,47.8 14.79,47.7 14.77,47.67 14.77,47.56 14.84,47.49 14.95,47.49 14.97,47.52 15.08,47.52 15.15,47.44 15.15,47.34 15.13,47.31 15.13,47.2 15.2,47.13 15.31,47.13 15.33,47.16 15.44,47.16 15.51,47.08 15.51,46.98 15.49,46.95 15.49,46.85 15.56,46.77 15.67,46.77 15.69,46.8 15.8,46.8 15.87,46.72 15.87,46.62 15.85,46.59 15.85,46.49 15.92,46.41 16.02,46.41 16.05,46.44 16.16,46.44 16.23,46.36 16.23,46.26 16.2,46.23 16.2,46.13 16.28,46.05 16.38,46.05 16.41,46.08 16.52,46.08 16.59,46 16.59,45.9 16.56,45.87 16.56,45.77 16.7,45.63 16.9,45.63 17.08,45.46 17.08,45.25 17.38,44.95 17.96,44.95 18.37,45.37 18.53,45.53 19.49,45.53 19.9,45.12 19.9,44.16 19.74,44 19.32,43.59 19.32,43.01 19.73,42.6 20.31,42.6 20.73,43.02 20.88,43.17 21.72,43.17 22.25,42.64 22.25,41.81 22.09,41.65 21.68,41.23 21.68,40.66 23.49,38.84 24.09,38.84 24.63,39.38 25.88,39.38 26.43,38.84 27.41,38.84 27.96,39.38 29.21,39.38 29.75,38.84 30.74,38.84 31.28,39.38 32.54,39.38 33.08,38.84 34.24,38.84 36,40.6 36,42.38 36.75,43.13 36.75,44.33 36.8,44.38
  vias: v1(12.19,48.87)
DSI_A1P: length 41.7
  TOP w0.076: 37.05,44.25 37.05,45.15 U1.H4
  TOP w0.127: 37.05,44.25 37.02,44.22 37.02,43.02 36.27,42.27 36.27,40.49 34.35,38.57 32.97,38.57 32.43,39.11 31.39,39.11 30.85,38.57 29.64,38.57 29.1,39.11 28.07,39.11 27.52,38.57 26.32,38.57 25.77,39.11 24.74,39.11 24.2,38.57 23.38,38.57 21.41,40.55 21.41,41.34 21.98,41.92 21.98,42.53 21.61,42.91 20.99,42.91 20.42,42.33 19.62,42.33 19.06,42.9 19.06,43.7 19.63,44.27 19.63,45.01 19.38,45.26 18.64,45.26 18.07,44.69 17.27,44.69 13.47,48.48 12.29,48.48 12.17,48.37 J4.25
  vias: v1(12.19,48.36)
DSI_A2N: length 42.4
  TOP w0.076: 37.94,43.46 37.94,44.39 37.8,44.53 U1.J6
  TOP w0.127: J4.11 12.16,42.87 12.28,42.75 13.05,42.75 13.25,42.55 13.35,42.55 13.4,42.6 13.5,42.6 13.58,42.53 13.58,42.42 13.53,42.37 13.53,42.27 13.61,42.19 13.71,42.19 13.76,42.24 13.86,42.24 13.94,42.17 13.94,42.06 13.89,42.01 13.89,41.91 13.96,41.83 14.07,41.83 14.12,41.88 14.22,41.88 14.3,41.81 14.3,41.7 14.25,41.65 14.25,41.55 14.32,41.47 14.43,41.47 14.48,41.52 14.58,41.52 14.66,41.45 14.66,41.34 14.61,41.3 14.61,41.19 14.68,41.12 14.79,41.12 14.84,41.16 14.94,41.16 15.02,41.09 15.02,40.98 14.97,40.94 14.97,40.83 15.04,40.76 15.15,40.76 15.19,40.8 15.3,40.8 15.37,40.73 15.37,40.62 15.33,40.58 15.33,40.47 15.44,40.36 15.6,40.36 15.68,40.28 15.68,40.12 20.81,34.99 21.52,34.99 22.38,35.85 23.32,35.85 24.19,34.99 24.85,34.99 25.74,35.88 26.62,35.88 27.51,34.99 28.17,34.99 29,35.82 30.01,35.82 30.84,34.99 34.43,34.99 38.64,39.19 38.64,42.75 37.94,43.46
  vias: v1(12.19,42.87)
DSI_A2P: length 41.8
  TOP w0.076: 38.19,44.27 38.19,44.48 38.05,44.62 38.05,45.15 U1.H6
  TOP w0.127: 38.19,44.27 38.19,43.58 38.91,42.86 38.91,39.08 34.54,34.72 30.73,34.72 29.9,35.55 29.11,35.55 28.28,34.72 27.4,34.72 26.51,35.61 25.85,35.61 24.96,34.72 24.3,34.72 24.07,34.72 23.21,35.58 22.49,35.58 21.63,34.72 21.41,34.72 20.7,34.72 12.94,42.48 12.3,42.48 12.19,42.37 J4.9
  vias: v1(12.18,42.37)
DSI_A3N: length 42.4
  TOP w0.076: 38.94,43.53 38.5,43.97 38.5,44.37 38.4,44.47 38.4,44.59 38.3,44.69 U1.J7
  TOP w0.127: J4.3 12.14,39.87 12.26,39.75 13.44,39.75 13.68,39.51 13.79,39.51 13.83,39.55 13.94,39.55 14.01,39.48 14.01,39.37 13.97,39.33 13.97,39.22 14.04,39.15 14.15,39.15 14.19,39.19 14.3,39.19 14.37,39.12 14.37,39.01 14.33,38.97 14.33,38.86 14.4,38.79 14.51,38.79 14.55,38.83 14.66,38.83 14.73,38.76 14.73,38.65 14.69,38.61 14.69,38.5 14.76,38.43 14.87,38.43 14.91,38.47 15.01,38.47 15.09,38.4 15.09,38.29 15.05,38.25 15.05,38.14 15.12,38.07 15.22,38.07 15.27,38.11 15.37,38.11 15.45,38.04 15.45,37.93 15.4,37.89 15.4,37.78 15.48,37.71 15.58,37.71 15.63,37.75 15.73,37.75 15.81,37.68 15.81,37.57 15.76,37.53 15.76,37.42 15.84,37.35 15.94,37.35 15.99,37.39 16.09,37.39 16.17,37.32 16.17,37.22 16.12,37.17 16.12,37.07 19.86,33.33 34.88,33.33 39.75,38.19 39.75,42.72 38.94,43.53
  vias: v1(12.17,39.86)
DSI_A3P: length 41.7
  TOP w0.076: 39.21,43.64 38.72,44.13 38.72,44.58 38.55,44.75 38.55,45.15 U1.H7
  TOP w0.127: 39.21,43.64 40.02,42.83 40.02,38.08 34.99,33.06 19.75,33.06 13.33,39.48 12.28,39.48 12.17,39.37 J4.1
  vias: v1(12.18,39.36)
DSI_ACLKN: length 42.4
  TOP w0.076: U1.J5 37.3,43.62
  TOP w0.127: J4.19 12.16,45.87 12.28,45.75 12.95,45.75 13.13,45.57 13.23,45.57 13.27,45.6 13.38,45.6 13.45,45.53 13.45,45.42 13.41,45.39 13.41,45.28 13.49,45.21 13.59,45.21 13.63,45.24 13.74,45.24 13.81,45.17 13.81,45.07 13.77,45.03 13.77,44.92 13.85,44.85 13.95,44.85 13.99,44.89 14.09,44.89 14.17,44.81 14.17,44.71 14.13,44.67 14.13,44.56 14.21,44.49 14.31,44.49 14.35,44.53 14.45,44.53 14.53,44.45 14.53,44.35 14.49,44.31 14.49,44.2 14.57,44.13 14.67,44.13 14.71,44.17 14.81,44.17 14.89,44.09 14.89,43.99 14.85,43.95 14.85,43.85 14.92,43.77 15.03,43.77 15.07,43.81 15.17,43.81 15.25,43.73 15.25,43.63 15.21,43.59 15.21,43.49 15.28,43.41 15.39,43.41 15.43,43.45 15.53,43.45 15.61,43.37 15.61,43.27 15.57,43.23 15.57,43.13 15.69,43.01 15.81,43.01 15.91,42.91 15.91,42.79 16.84,41.86 17.42,41.86 17.64,42.09 18.4,42.09 19.01,41.48 19.01,40.72 18.78,40.49 18.78,39.92 19.19,39.51 19.77,39.51 20,39.73 20.8,39.73 21.36,39.17 21.36,38.37 21.13,38.14 21.13,37.56 21.77,36.93 22.19,36.93 22.93,37.67 23.96,37.67 24.7,36.93 25.51,36.93 26.26,37.67 27.29,37.67 28.03,36.93 28.84,36.93 29.6,37.69 30.6,37.69 31.36,36.93 34.17,36.93 37.3,40.06 37.3,43.62
  vias: v1(12.19,45.86)
DSI_ACLKP: length 41.8
  TOP w0.076: U1.H5 37.55,45.15 37.55,44.8 37.55,44.8 37.55,44.23
  TOP w0.127: 37.55,44.23 37.57,44.21 37.57,43.62 37.57,39.95 34.28,36.66 31.25,36.66 30.49,37.42 29.71,37.42 28.95,36.66 27.92,36.66 27.18,37.41 26.37,37.41 25.62,36.66 24.59,36.66 23.85,37.41 23.04,37.41 22.3,36.66 21.66,36.66 20.87,37.45 20.87,38.25 21.09,38.48 21.09,39.06 20.68,39.47 20.11,39.47 19.88,39.24 19.08,39.24 18.51,39.8 18.51,40.6 18.74,40.83 18.74,41.37 18.29,41.82 17.75,41.82 17.53,41.59 16.73,41.59 12.84,45.48 12.27,45.48 12.15,45.37 J4.17
  vias: v1(12.18,45.36)
DSI_B0N: length 42.1
  TOP w0.127: U1.C1 v1(34.79,48.22) ; J4.36 5.38,51.88 v2(3.71,51.88)
  L3_SIG w0.076: 32.77,49.49 34.04,48.22 v1(34.79,48.22)
  L3_SIG w0.127: v2(3.71,51.88) 3.89,51.77 4.35,51.77 4.43,51.84 4.43,51.96 4.5,52.03 4.61,52.03 4.68,51.96 4.68,51.84 4.76,51.77 4.86,51.77 4.93,51.84 4.93,51.96 5.01,52.03 5.11,52.03 5.19,51.96 5.19,51.84 5.26,51.77 5.37,51.77 5.44,51.84 5.44,51.96 5.52,52.03 5.62,52.03 5.7,51.96 5.7,51.84 5.77,51.77 5.88,51.77 5.95,51.84 5.95,51.96 6.03,52.03 6.13,52.03 6.2,51.96 6.2,51.84 6.28,51.77 6.38,51.77 6.46,51.84 6.46,51.96 6.53,52.03 6.64,52.03 6.71,51.96 6.71,51.84 6.79,51.77 10.63,51.77 11.68,50.71 15.68,50.71 18.8,53.83 19.71,53.83 20.12,54.24 20.12,54.55 20.71,55.13 21.54,55.13 22.13,54.55 22.13,54.24 22.54,53.83 23.12,53.83 23.53,54.24 23.53,54.55 24.11,55.13 24.95,55.13 25.53,54.55 25.53,54.24 25.94,53.83 27.86,53.83 31.46,50.23 32.03,50.23 32.77,49.49 32.77,49.49
DSI_B0P: length 41.5
  TOP w0.127: U1.C2 36.14,47.9 v1(36.16,47.92) ; v2(3.71,51.35) 5.38,51.35 J4.34
  L3_SIG w0.076: v1(36.16,47.92) 33.9,47.92 33.72,48.11
  L3_SIG w0.127: v2(3.71,51.35) 3.89,51.46 10.5,51.46 11.56,50.41 15.81,50.41 18.92,53.52 19.84,53.52 20.43,54.11 20.43,54.42 20.84,54.83 21.42,54.83 21.82,54.42 21.82,54.11 22.41,53.52 23.24,53.52 23.83,54.11 23.83,54.42 24.24,54.83 24.82,54.83 25.23,54.42 25.23,54.11 25.82,53.52 27.74,53.52 31.34,49.92 31.91,49.92 32.46,49.36 33.72,48.11 33.72,48.11
DSI_B1N: length 42.3
  TOP w0.127: U1.D1 v1(34.79,47.59) ; J4.28 5.38,48.88 v2(3.71,48.88)
  L3_SIG w0.076: v1(34.79,47.59) 34.79,47.59 32.26,47.59
  L3_SIG w0.127: v2(3.71,48.88) 3.89,48.77 4.35,48.77 4.43,48.84 4.43,48.92 4.5,49 4.61,49 4.68,48.92 4.68,48.84 4.76,48.77 4.86,48.77 4.94,48.84 4.94,48.92 5.01,49 5.12,49 5.19,48.92 5.19,48.84 5.27,48.77 5.37,48.77 5.45,48.84 5.45,48.92 5.52,49 5.62,49 5.7,48.92 5.7,48.84 5.77,48.77 5.88,48.77 5.95,48.84 5.95,48.92 6.03,49 6.13,49 6.21,48.92 6.21,48.84 6.28,48.77 6.39,48.77 6.46,48.84 6.46,48.92 6.54,49 6.64,49 6.72,48.92 6.72,48.84 6.79,48.77 6.89,48.77 6.97,48.84 6.97,48.92 7.04,49 7.15,49 7.22,48.92 7.22,48.84 7.3,48.77 7.4,48.77 7.48,48.84 7.48,48.92 7.55,49 7.66,49 7.73,48.92 7.73,48.84 7.81,48.77 10.92,48.77 11.75,47.94 15.07,47.94 17.16,50.04 18.5,50.04 19.08,49.45 19.08,48.68 19.49,48.27 20.07,48.27 20.48,48.68 20.48,49.45 21.07,50.04 21.9,50.04 22.49,49.45 22.49,48.68 22.9,48.27 23.48,48.27 23.89,48.68 23.89,49.45 24.47,50.04 29.32,50.04 31.77,47.59 32.26,47.59
DSI_B1P: length 41.7
  TOP w0.127: U1.D2 v1(36.2,47.18) ; J4.26 5.38,48.35 v2(3.71,48.35)
  L3_SIG w0.076: 33.71,47.28 35.74,47.28 35.85,47.18 v1(36.2,47.18)
  L3_SIG w0.127: 33.71,47.28 31.65,47.28 29.2,49.73 24.6,49.73 24.19,49.32 24.19,48.56 23.6,47.97 22.77,47.97 22.18,48.56 22.18,49.32 21.77,49.73 21.2,49.73 20.79,49.32 20.79,48.56 20.2,47.97 19.37,47.97 18.78,48.56 18.78,49.32 18.37,49.73 17.29,49.73 15.19,47.63 11.62,47.63 10.79,48.46 3.89,48.46 v2(3.71,48.35)
DSI_B2N: length 42.4
  TOP w0.127: U1.F1 v1(34.79,46.34) ; v2(3.71,42.88) 5.38,42.88 J4.12
  L3_SIG w0.076: 32.29,46.27 34.38,46.27 34.45,46.34 v1(34.79,46.34)
  L3_SIG w0.127: 32.29,46.27 31.12,46.27 30.59,45.74 25.89,41.04 22.62,41.04 22.21,41.45 22.21,41.72 21.62,42.31 20.79,42.31 20.21,41.72 20.21,41.45 19.8,41.04 19.22,41.04 18.81,41.45 18.81,41.72 18.22,42.31 17.39,42.31 16.8,41.72 16.8,41.45 16.39,41.04 15.81,41.04 15.41,41.45 15.41,41.72 14.82,42.31 13.99,42.31 13.4,41.72 13.4,41.45 12.99,41.04 12.61,41.04 10.9,42.75 7.27,42.75 7.2,42.82 7.2,42.93 7.12,43 7.02,43 6.94,42.93 6.94,42.82 6.87,42.75 6.77,42.75 6.69,42.82 6.69,42.93 6.62,43 6.51,43 6.44,42.93 6.44,42.82 6.36,42.75 6.26,42.75 6.18,42.82 6.18,42.93 6.11,43 6,43 5.93,42.93 5.93,42.82 5.85,42.75 5.75,42.75 5.67,42.82 5.67,42.93 5.6,43 5.5,43 5.42,42.93 5.42,42.82 5.35,42.75 5.24,42.75 5.17,42.82 5.17,42.93 5.09,43 4.99,43 4.91,42.93 4.91,42.82 4.84,42.75 4.73,42.75 4.66,42.82 4.66,42.93 4.58,43 4.48,43 4.4,42.93 4.4,42.82 4.33,42.75 3.91,42.75 v2(3.71,42.88)
DSI_B2P: length 41.8
  TOP w0.127: U1.F2 v1(36.2,46.18) ; v2(3.71,42.35) 5.38,42.35 J4.10
  L3_SIG w0.076: v1(36.2,46.18) 35.81,46.18 35.66,46.03 34.56,46.03 34.49,45.96 33.74,45.96
  L3_SIG w0.127: v2(3.71,42.35) 3.87,42.44 10.77,42.44 12.48,40.74 13.12,40.74 13.7,41.32 13.7,41.6 14.11,42.01 14.69,42.01 15.1,41.6 15.1,41.32 15.69,40.74 16.52,40.74 17.11,41.32 17.11,41.6 17.52,42.01 18.1,42.01 18.5,41.6 18.5,41.32 19.09,40.74 19.92,40.74 20.51,41.32 20.51,41.6 20.92,42.01 21.5,42.01 21.91,41.6 21.91,41.32 22.5,40.74 26.01,40.74 30.72,45.44 31.24,45.96 33.74,45.96
DSI_B3N: length 42.3
  TOP w0.127: U1.G1 34.8,45.72 v1(34.8,45.73) ; v2(3.71,39.88) 5.38,39.88 J4.4
  L3_SIG w0.076: 32.8,44.36 34.15,45.71 34.79,45.71 v1(34.8,45.73)
  L3_SIG w0.127: 32.8,44.36 32.43,43.99 31.67,43.99 25.48,37.8 22.11,37.8 21.7,38.21 21.7,38.3 21.11,38.88 20.28,38.88 19.69,38.3 19.69,38.21 19.28,37.8 18.7,37.8 18.3,38.21 18.3,38.3 17.71,38.88 16.88,38.88 16.29,38.3 16.29,38.21 15.88,37.8 15.3,37.8 14.89,38.21 14.89,38.3 14.3,38.88 13.47,38.88 12.89,38.3 12.89,38.21 12.45,37.77 11.47,37.77 9.47,39.77 7.23,39.77 7.16,39.85 7.16,39.93 7.08,40.01 6.98,40.01 6.91,39.93 6.91,39.85 6.83,39.77 6.73,39.77 6.65,39.85 6.65,39.93 6.58,40.01 6.47,40.01 6.4,39.93 6.4,39.85 6.32,39.77 6.22,39.77 6.14,39.85 6.14,39.93 6.07,40.01 5.96,40.01 5.89,39.93 5.89,39.85 5.81,39.77 5.71,39.77 5.64,39.85 5.64,39.93 5.56,40.01 5.46,40.01 5.38,39.93 5.38,39.85 5.31,39.77 5.2,39.77 5.13,39.85 5.13,39.93 5.05,40.01 4.95,40.01 4.87,39.93 4.87,39.85 4.8,39.77 4.69,39.77 4.62,39.85 4.62,39.93 4.54,40.01 4.44,40.01 4.37,39.93 4.37,39.85 4.29,39.77 3.88,39.77 v2(3.71,39.88)
DSI_B3P: length 41.7
  TOP w0.127: v2(3.71,39.35) 5.38,39.35 J4.2 ; U1.G2 v1(36.09,45.69)
  L3_SIG w0.076: v1(36.09,45.69) 35.72,45.69 35.31,45.4 34.27,45.4 33.84,44.98
  L3_SIG w0.127: 33.84,44.98 33.84,44.97 32.56,43.69 31.8,43.69 25.61,37.5 21.98,37.5 21.39,38.08 21.39,38.17 20.99,38.58 20.41,38.58 20,38.17 20,38.08 19.41,37.5 18.58,37.5 17.99,38.08 17.99,38.17 17.58,38.58 17,38.58 16.59,38.17 16.59,38.08 16.01,37.5 15.17,37.5 14.59,38.08 14.59,38.17 14.18,38.58 13.6,38.58 13.19,38.17 13.19,38.08 12.57,37.47 11.34,37.47 9.34,39.47 3.89,39.47 v2(3.71,39.35)
DSI_BCLKN: length 42.4
  TOP w0.127: v2(3.71,45.88) 5.38,45.88 J4.20 ; U1.E1 v1(34.79,46.97)
  L3_SIG w0.076: v1(34.79,46.97) 34.78,46.96 33.21,46.96
  L3_SIG w0.127: 33.21,46.96 25.98,46.96 23.36,44.33 22.33,44.33 22.16,44.5 22.16,45.11 21.57,45.7 20.75,45.7 20.16,45.11 20.16,44.5 19.75,44.09 19.17,44.09 18.76,44.5 18.76,45.11 18.17,45.7 17.34,45.7 16.75,45.11 16.75,44.5 16.34,44.09 15.77,44.09 15.36,44.5 15.36,45.11 14.91,45.55 13.79,45.55 13.35,45.11 13.35,44.68 13.04,44.37 11.99,44.37 10.6,45.76 7.23,45.76 7.16,45.84 7.16,45.92 7.08,45.99 6.98,45.99 6.91,45.92 6.91,45.84 6.83,45.76 6.73,45.76 6.65,45.84 6.65,45.92 6.58,45.99 6.47,45.99 6.4,45.92 6.4,45.84 6.32,45.76 6.22,45.76 6.14,45.84 6.14,45.92 6.07,45.99 5.96,45.99 5.89,45.92 5.89,45.84 5.81,45.76 5.71,45.76 5.64,45.84 5.64,45.92 5.56,45.99 5.46,45.99 5.38,45.92 5.38,45.84 5.31,45.76 5.2,45.76 5.13,45.84 5.13,45.92 5.05,45.99 4.95,45.99 4.87,45.92 4.87,45.84 4.8,45.76 4.69,45.76 4.62,45.84 4.62,45.92 4.54,45.99 4.44,45.99 4.37,45.92 4.37,45.84 4.29,45.76 3.89,45.76 v2(3.71,45.88)
DSI_BCLKP: length 41.8
  TOP w0.127: v2(3.71,45.35) 5.38,45.35 J4.18 ; U1.E2 v1(36.08,46.68)
  L3_SIG w0.076: 33.53,46.65 35.55,46.65 35.57,46.68 v1(36.08,46.68)
  L3_SIG w0.127: v2(3.71,45.35) 3.89,45.46 10.47,45.46 11.86,44.07 13.17,44.07 13.66,44.56 13.66,44.98 13.92,45.25 14.79,45.25 15.05,44.98 15.05,44.38 15.64,43.79 16.47,43.79 17.06,44.38 17.06,44.98 17.47,45.39 18.05,45.39 18.46,44.98 18.46,44.38 19.04,43.79 19.87,43.79 20.46,44.38 20.46,44.98 20.88,45.4 21.45,45.4 21.86,44.98 21.86,44.38 22.21,44.03 23.48,44.03 26.11,46.65 33.53,46.65
EDP_AUXN: length 6
  TOP w0.127: C72.2 57.86,39.6 59.56,39.6 60.06,39.1 ; 60.06,39.1 60.06,39.66 60.15,39.75 60.3,39.75 60.53,39.52 60.53,39.28 60.6,39.2 60.71,39.2 60.78,39.28 60.78,39.45 60.83,39.5 J6.35 ; 60.06,39.1 R114.2
EDP_AUXP: length 4.9
  TOP w0.127: J6.33 60.44,40 R115.1 59.52,39.87 57.91,39.87 C71.2
EDP_BL_ENABLE: length 66.2
  TOP w0.254: 69.39,44.5 J6.22
  TOP w0.356: R186.1 45.72,66.09 46.38,66.75 54.23,66.75 57.25,69.77 v2(57.58,69.77) ; v2(77.65,69.77) 77.65,49.72 72.53,44.6 69.49,44.6 69.39,44.5
  BOTTOM w0.356: v2(77.65,69.77) v2(57.58,69.77)
EDP_BL_ENABLE_R: length 1.9
  TOP w0.254: U11.3 45.7,64.25 R186.2
EDP_BL_PWR: length 107.2
  TOP w0.635: v2(78.96,89.27) 82.6,85.62 82.6,64.72 80.49,62.61 80.49,48.02 71.43,38.96 70.11,38.96
  BOTTOM w1.016: v2(78.96,89.27) 78.26,89.97 38.23,89.97 36.83,91.36 J20.1
EDP_LCD_VCC: length 40.4
  TOP w0.305: J6.12 69.42,48.5 69.62,48.69 69.32,49 J6.10
  TOP w0.635: J21.1 75.02,75.66 75.02,52.11 71.61,48.69 69.62,48.69
EDP_ML0N: length 2.2
  TOP w0.127: J6.25 60.03,43 C69.2
EDP_ML0P: length 2.2
  TOP w0.127: C70.2 60.02,42.5 J6.27
EDP_ML1N: length 2.2
  TOP w0.127: C67.2 60,46 J6.17
EDP_ML1P: length 2.2
  TOP w0.127: J6.19 60.02,45.5 C68.2
EDP_ML2N: length 2.2
  TOP w0.127: C65.2 60,49 J6.9
EDP_ML2P: length 2.2
  TOP w0.127: C66.2 59.97,48.5 J6.11
EDP_ML3N: length 2.2
  TOP w0.127: J6.1 60.04,52 C63.2
EDP_ML3P: length 2.2
  TOP w0.127: C64.2 59.98,51.5 J6.3
EDP_PWM_DIM: length 64.4
  TOP w0.254: 69.67,44 J6.24
  TOP w0.356: R187.1 49.56,65.41 50.06,65.91 54.61,65.91 v2(57.58,68.88) ; v2(79.48,68.88) 79.22,68.63 79.22,49.83 73.39,44 69.67,44
  BOTTOM w0.356: v2(79.48,68.88) v2(57.58,68.88)
EDP_PWM_DIM_R: length 1.9
  TOP w0.254: R187.2 49.53,62.41 U12.3
EDP_SELF_TEST: length 3.4
  TOP w0.203: J6.14 70.99,47.5 R192.1
EN1P2: length 3.2
  TOP w0.356: C43.1 46.05,77.19 R79.2 44.76,77.28 U8.11
EN1P8: length 3.4
  TOP w0.356: U9.11 38.92,65.76 38.95,65.74 R87.2 40.77,65.74 C47.1
EXT_REFCLK: length 22.5
  L3_SIG w0.356: J17.1 40.2,34.07 43.71,37.59 43.71,43.23 41.82,45.12 41.82,46.04 41.2,46.66 41.2,49.02 40.79,49.43 40.79,50.93 39.94,51.78 v2(39.13,51.78)
  BOTTOM w0.356: v2(39.13,51.78) 38.67,51.78 R105.1
FB_1PT2V: length 3.4
  TOP w0.356: R84.2 41.64,83.21 R82.1 41.64,82.46 41.74,82.37 U8.16
FB_1PT8V: length 3.4
  TOP w0.356: R90.2 37.26,71.7 R89.1 36.18,71.07 36.3,70.95 U9.16
FX_CLKN: length 56.1
  BOTTOM w0.127: J1.27 8.79,10.74 8.67,10.87 8.67,14.03 15.05,20.41 15.05,21.12 15.46,21.53 16.43,21.53 16.99,22.1 16.99,22.9 16.43,23.46 15.46,23.46 15.05,23.87 15.05,24.45 15.46,24.86 16.43,24.86 16.99,25.42 16.99,26.22 16.43,26.79 15.46,26.79 15.05,27.2 15.05,27.78 15.46,28.19 16.43,28.19 16.99,28.75 16.99,29.55 16.43,30.12 15.46,30.12 15.05,30.52 15.05,31.1 15.46,31.51 16.43,31.51 16.99,32.08 16.99,32.88 16.43,33.44 15.46,33.44 15.05,33.85 15.05,34.69 11.25,38.49 11.25,43.37 11.91,44.02 14.43,44.02 14.89,44.48 14.89,45.26 14.41,45.74 12.87,45.74 R7.2
FX_CLKP: length 56.1
  BOTTOM w0.127: R6.2 12.85,45.47 13.09,45.47 13.16,45.4 13.16,45.35 13.24,45.27 13.34,45.27 13.42,45.35 13.42,45.4 13.49,45.47 13.6,45.47 13.67,45.4 13.67,45.35 13.75,45.27 13.85,45.27 13.93,45.35 13.93,45.4 14,45.47 14.3,45.47 14.62,45.15 14.62,44.59 14.32,44.29 11.8,44.29 10.99,43.48 10.99,38.38 14.78,34.58 14.78,33.74 15.35,33.18 16.32,33.18 16.73,32.77 16.73,32.19 16.32,31.78 15.35,31.78 14.78,31.21 14.78,30.41 15.35,29.85 16.32,29.85 16.73,29.44 16.73,28.86 16.32,28.45 15.35,28.45 14.78,27.89 14.78,27.09 15.35,26.52 16.32,26.52 16.73,26.11 16.73,25.53 16.32,25.12 15.35,25.12 14.78,24.56 14.78,23.76 15.35,23.19 16.32,23.19 16.73,22.79 16.73,22.21 16.32,21.8 15.35,21.8 14.78,21.23 14.78,20.52 8.4,14.14 8.4,10.87 8.27,10.74 J1.29
FX_N0: length 56.1
  BOTTOM w0.127: R9.2 12.86,51.75 14.38,51.75 19.76,46.37 23.39,46.37 29.56,40.19 29.56,22.31 39.15,12.72 39.15,10.87 39.27,10.74 J1.3
FX_N1: length 56.1
  BOTTOM w0.127: R11.2 12.88,48.74 14.79,48.74 19.11,44.42 20.77,44.42 26.7,38.5 26.7,36.73 27.1,36.32 27.41,36.32 27.98,35.76 27.98,34.96 27.41,34.39 27.1,34.39 26.7,33.98 26.7,33.4 27.1,32.99 27.41,32.99 27.98,32.43 27.98,31.63 27.41,31.06 27.1,31.06 26.7,30.66 26.7,30.08 27.1,29.67 27.41,29.67 27.98,29.1 27.98,28.3 27.41,27.74 27.1,27.74 26.7,27.33 26.7,26.75 27.1,26.34 27.41,26.34 27.98,25.77 27.98,24.98 27.41,24.41 27.1,24.41 26.7,24 26.7,23.42 27.1,23.01 27.41,23.01 27.98,22.45 27.98,21.65 27.41,21.08 27.1,21.08 26.7,20.67 26.7,19.53 31.53,14.7 31.53,10.87 31.65,10.74 J1.9
FX_N2: length 56.2
  BOTTOM w0.127: J1.15 24.03,10.74 23.91,10.87 23.91,13.9 24.32,14.31 24.98,14.31 25.54,14.87 25.54,15.67 24.98,16.24 24.32,16.24 23.91,16.65 23.91,17.23 24.32,17.64 24.98,17.64 25.54,18.2 25.54,19 24.98,19.57 24.32,19.57 23.91,19.98 23.91,20.55 24.32,20.96 24.98,20.96 25.54,21.53 25.54,22.33 24.98,22.89 24.32,22.89 23.91,23.3 23.91,23.88 24.32,24.29 24.98,24.29 25.54,24.86 25.54,25.66 24.98,26.22 24.32,26.22 23.91,26.63 23.91,27.21 24.32,27.62 24.98,27.62 25.54,28.18 25.54,28.98 24.98,29.55 24.32,29.55 23.91,29.96 23.91,30.54 24.32,30.95 24.98,30.95 25.54,31.51 25.54,32.31 24.98,32.88 24.32,32.88 23.91,33.29 23.91,33.86 24.32,34.27 24.98,34.27 25.54,34.84 25.54,35.64 24.98,36.2 24.32,36.2 23.91,36.61 23.91,37.6 18.76,42.75 12.86,42.75 R13.2
FX_N3: length 56.1
  BOTTOM w0.127: R15.2 12.84,39.75 15.53,39.75 18.57,36.71 18.57,35.67 18.98,35.26 20.69,35.26 21.25,34.69 21.25,33.89 20.69,33.33 18.98,33.33 18.57,32.92 18.57,32.34 18.98,31.93 20.69,31.93 21.25,31.36 21.25,30.56 20.69,30 18.98,30 18.57,29.59 18.57,29.01 18.98,28.6 20.69,28.6 21.25,28.04 21.25,27.24 20.69,26.67 18.98,26.67 18.57,26.26 18.57,25.68 18.98,25.28 20.69,25.28 21.25,24.71 21.25,23.91 20.69,23.34 18.98,23.34 18.57,22.94 18.57,22.36 18.98,21.95 20.69,21.95 21.14,21.49 21.14,20.47 20.69,20.02 18.98,20.02 18.57,19.61 18.57,14.98 16.29,12.69 16.29,10.87 16.41,10.74 J1.21
FX_P0: length 56.1
  BOTTOM w0.127: R8.2 12.74,51.37 12.85,51.48 13.06,51.48 13.13,51.41 13.13,51.36 13.21,51.29 13.31,51.29 13.39,51.36 13.39,51.41 13.46,51.48 13.57,51.48 13.64,51.41 13.64,51.36 13.72,51.29 13.82,51.29 13.89,51.36 13.89,51.41 13.97,51.48 14.27,51.48 19.65,46.1 23.27,46.1 29.3,40.08 29.3,22.2 38.88,12.61 38.88,10.87 38.75,10.74 J1.5
FX_P1: length 56.1
  BOTTOM w0.127: R10.2 12.86,48.48 13.13,48.48 13.2,48.4 13.2,48.39 13.28,48.32 13.38,48.32 13.46,48.39 13.46,48.4 13.53,48.48 13.64,48.48 13.71,48.4 13.71,48.39 13.78,48.32 13.89,48.32 13.96,48.39 13.96,48.4 14.04,48.48 14.14,48.48 14.22,48.4 14.22,48.39 14.29,48.32 14.4,48.32 14.47,48.39 14.47,48.4 14.55,48.48 14.68,48.48 19,44.16 20.66,44.16 26.43,38.39 26.43,36.62 26.99,36.06 27.3,36.06 27.71,35.65 27.71,35.07 27.3,34.66 26.99,34.66 26.43,34.09 26.43,33.29 26.99,32.73 27.3,32.73 27.71,32.32 27.71,31.74 27.3,31.33 26.99,31.33 26.43,30.77 26.43,29.97 26.99,29.4 27.3,29.4 27.71,28.99 27.71,28.41 27.3,28 26.99,28 26.43,27.44 26.43,26.64 26.99,26.07 27.3,26.07 27.71,25.66 27.71,25.09 27.3,24.68 26.99,24.68 26.43,24.11 26.43,23.31 26.99,22.75 27.3,22.75 27.71,22.34 27.71,21.76 27.3,21.35 26.99,21.35 26.43,20.78 26.43,19.42 31.26,14.59 31.26,10.87 31.13,10.74 J1.11
FX_P2: length 56.1
  BOTTOM w0.127: J1.17 23.51,10.74 23.64,10.87 23.64,14.01 24.21,14.58 24.87,14.58 25.28,14.99 25.28,15.56 24.87,15.97 24.21,15.97 23.64,16.54 23.64,17.34 24.21,17.9 24.87,17.9 25.28,18.31 25.28,18.89 24.87,19.3 24.21,19.3 23.64,19.87 23.64,20.67 24.21,21.23 24.87,21.23 25.28,21.64 25.28,22.22 24.87,22.63 24.21,22.63 23.64,23.19 23.64,23.99 24.21,24.56 24.87,24.56 25.28,24.97 25.28,25.55 24.87,25.96 24.21,25.96 23.64,26.52 23.64,27.32 24.21,27.89 24.87,27.89 25.28,28.29 25.28,28.87 24.87,29.28 24.21,29.28 23.64,29.85 23.64,30.65 24.21,31.21 24.87,31.21 25.28,31.62 25.28,32.2 24.87,32.61 24.21,32.61 23.64,33.18 23.64,33.97 24.21,34.54 24.87,34.54 25.28,34.95 25.28,35.53 24.87,35.94 24.21,35.94 23.64,36.5 23.64,37.49 18.65,42.48 14.6,42.48 14.53,42.4 14.53,42.4 14.45,42.32 14.35,42.32 14.27,42.4 14.27,42.4 14.2,42.48 14.09,42.48 14.02,42.4 14.02,42.4 13.94,42.32 13.84,42.32 13.76,42.4 13.76,42.4 13.69,42.48 13.58,42.48 13.51,42.4 13.51,42.4 13.44,42.32 13.33,42.32 13.26,42.4 13.26,42.4 13.18,42.48 12.85,42.48 R12.2
FX_P3: length 56.1
  BOTTOM w0.127: R14.2 12.87,39.49 13.14,39.49 13.27,39.35 13.39,39.35 13.53,39.49 13.65,39.49 13.78,39.35 13.9,39.35 14.03,39.49 14.15,39.49 14.29,39.35 14.41,39.35 14.54,39.49 14.66,39.49 14.8,39.35 14.92,39.35 15.05,39.49 15.42,39.49 18.3,36.6 18.3,35.56 18.87,34.99 20.58,34.99 20.99,34.58 20.99,34 20.58,33.59 18.87,33.59 18.3,33.03 18.3,32.23 18.87,31.66 20.58,31.66 20.99,31.25 20.99,30.68 20.58,30.27 18.87,30.27 18.3,29.7 18.3,28.9 18.87,28.34 20.58,28.34 20.99,27.93 20.99,27.35 20.58,26.94 18.87,26.94 18.3,26.37 18.3,25.57 18.87,25.01 20.58,25.01 20.99,24.6 20.99,24.02 20.58,23.61 18.87,23.61 18.3,23.05 18.3,22.25 18.87,21.68 20.58,21.68 20.88,21.38 20.88,20.58 20.58,20.28 18.87,20.28 18.3,19.72 18.3,15.09 16.02,12.81 16.02,10.87 15.89,10.74 J1.23
GPIO1: length 60.1
  TOP w0.076: 36.8,49.41 U1.A4
  TOP w0.127: 36.8,49.41 36.65,49.56 36.65,50.29 35.97,50.98 35.43,50.98 35.13,51.28 v2(35.13,54.79)
  TOP w0.356: R54.1 SW2.16 v2(18.29,74.68)
  L3_SIG w0.356: v2(35.13,54.79) 32.41,57.51 31.77,57.51 29.36,59.92 20.98,59.92 16.97,63.92 16.97,69.56 18.29,70.88 v2(18.29,74.68)
  BOTTOM w0.356: J16.1 10.17,82.8 v2(18.29,74.68)
GPIO2: length 60.9
  TOP w0.076: 37.19,49.76 37.24,49.71 37.24,49.23 37.3,49.16 U1.A5
  TOP w0.127: 37.19,49.76 37.16,49.78 37.16,50.55 36.63,51.08 36.63,51.38 36.12,51.89 36.12,52.81 36.42,53.11 37.01,53.11 37.95,54.05 v2(37.95,54.81)
  TOP w0.356: R55.1 SW2.15 v2(19.56,74.7)
  L3_SIG w0.356: v2(37.95,54.81) 37.89,54.76 36.78,54.76 33.28,58.26 32.18,58.26 29.77,60.67 21.96,60.67 18.87,63.76 18.87,67.73 19.56,68.41 v2(19.56,74.7)
  BOTTOM w0.356: J16.2 12.71,81.55 v2(19.56,74.7)
GPIO3: length 85.8
  TOP w0.076: U1.A6 37.8,49.79
  TOP w0.127: 37.8,49.79 37.92,49.91
  TOP w0.203: 38.89,52.5 38.71,52.68 38.1,52.68 37.82,52.4 37.82,51.97 37.92,51.87 37.92,49.91
  TOP w0.254: 43.87,61.26 45.62,61.26 45.7,61.18 U11.4
  TOP w0.356: R56.1 SW2.14 v2(20.83,74.7) ; v2(37.26,60.27) 38.25,61.26 43.87,61.26 43.87,57.45 44.12,57.2 44.12,55.04 43.33,54.25 42.06,54.25 40.11,52.3 39.09,52.3 38.89,52.5
  BOTTOM w0.356: J16.3 15.25,80.28 v2(20.83,74.7) 20.83,74.7 20.83,73.36 20.15,72.69 20.15,66.93 20.4,66.67 20.4,57.53 23.65,54.28 27.66,54.28 31.83,58.45 31.83,60.5 32.33,61.01 35.44,61.01 36.17,60.27 v2(37.26,60.27)
GPIO4: length 88.9
  TOP w0.076: U1.B4 36.8,48.42 36.56,48.66 36.56,49.29 36.45,49.4
  TOP w0.127: v2(33.71,54.31) 34.8,53.21 34.8,51.18 35.26,50.72 35.84,50.72 36.4,50.16 36.4,49.45 36.45,49.4
  TOP w0.254: 49.5,59.49 49.5,60.78 U12.4
  TOP w0.356: 49.5,59.49 49.05,59.03 49.05,56.9 48.49,56.34 v2(47.57,56.34) ; v2(22.1,74.65) SW2.13 R57.1
  L3_SIG w0.356: v2(33.71,54.31) 28.94,59.07 20.5,59.07 15.82,63.75 15.82,74.92 16.97,76.08 20.84,76.08 22.1,74.82 v2(22.1,74.65)
  BOTTOM w0.356: v2(47.57,56.34) 46.08,57.84 36.4,57.84 33.71,55.14 v2(33.71,54.31) ; J16.4 17.79,81.56 17.48,81.26 17.48,79.27 v2(22.1,74.65)
HPD: length 145.4
  TOP w0.254: 66.16,47 J6.16 69.84,47
  TOP w0.356: 69.84,47 70.71,46.13 72.9,46.13 76.94,50.16 v2(76.94,57.51) ; 66.16,47 65.56,47.6 65.56,54.38 64.9,55.04 59.41,55.04 ; 59.41,55.04 v2(47.35,55.04) ; 59.41,55.04 59.49,55.13 59.49,69.93 58.64,70.78 56.2,70.78 54.37,68.95 50.97,68.95 49.83,70.09 49.83,83.77 43.7,89.9 29.24,89.9 27.95,88.6 J16.8
  BOTTOM w0.254: v2(76.94,57.51) 76.96,57.53 79.92,57.53 82.4,55.05 82.4,53.29 82.1,52.99 J9.18
  BOTTOM w0.356: v2(47.35,55.04) 47.88,54.51 47.88,44.68 43.61,40.41 38.4,40.41 38.1,40.72 v2(38.1,41.4) 37.59,41.91 R111.1
I2C_3V3EN: length 82.8
  TOP w0.254: U6.6 76.19,94.19
  TOP w0.356: 76.19,94.19 75.82,93.82 75.82,89.53 v2(74.69,88.4) ; R61.1 SW2.9 v2(27.18,74.63)
  BOTTOM w0.356: v2(74.69,88.4) 73.74,87.45 38.71,87.45 32.74,93.43 25.97,93.43 24.19,91.64 24.19,87.2 25.41,85.97 25.41,76.45 27.18,74.68 v2(27.18,74.63)
I2C_SCL: length 202.4
  TOP w0.127: U1.H1 34.7,45.03 v3(34.7,45.03)
  TOP w0.254: J4.40 6.82,53.37
  TOP w0.356: v2(33.31,31.59) 33.31,31.28 32.56,30.53 32.56,19.74 38.99,13.31 38.99,9.5 J1.4 ; 6.82,53.37 7.18,53.72 7.18,56.65 7.86,57.33 12.69,57.33 13.14,57.79 14.03,57.79 14.04,57.77 14.78,57.77 R3.2 15.91,57.74 25.78,47.87 v2(29.08,47.87) 30.28,46.67 33.06,46.67 v3(34.7,45.03) ; R76.1 v2(73.76,91.54)
  L3_SIG w0.356: v2(73.76,91.54) 62.31,91.54 58.47,87.7 58.47,84.44 J19.2 ; v2(33.31,31.59) 33.31,31.64 34.75,33.08 34.75,44.98 v3(34.7,45.03)
  BOTTOM w0.356: v2(29.08,47.87) 29.08,52.7 35.42,59.03 47.5,59.03 48.41,59.94 48.41,70.98 52.94,75.5 56.83,75.5 59.25,77.92 59.25,80.33 J19.2 56.26,86.64 38.38,86.64 33.67,91.35 26.68,91.35 25.41,90.08 J16.7
I2C_SCL_3P3V: length 89.3
  TOP w0.254: 74.56,96.26 U6.1 73.6,95.19 73.59,95.17 R77.2
  TOP w0.356: 72.56,98.26 65.71,105.1 52.15,105.1 48.94,108.31 48.94,110.3 J10.1 ; 72.56,98.26 72.99,97.83 ; 72.56,98.26 70.99,96.7 70.99,94.01 72.26,92.74 R117.2 ; 72.99,97.83 76.89,101.73 77.13,101.97 U13.4 ; 72.99,97.83 74.56,96.26
I2C_SDA: length 190.5
  TOP w0.254: v3(34.25,44.38) 34.33,44.46 34.79,44.46 U1.J1 ; J4.39 11.13,54
  TOP w0.356: J1.6 36.47,9.47 36.47,14.05 31.62,18.9 31.62,30.89 32.44,31.71 v2(32.46,31.71) ; v3(34.25,44.38) 34.25,44.36 33.7,43.81 30.42,43.81 29.13,45.1 29.13,45.11 v2(28.51,45.73) 26.31,45.73 16.5,55.54 v2(15.63,55.54) R4.2 14.18,55.54 14.16,55.57 12.71,55.57 11.13,54 ; R75.1 76.72,91.61 v2(76.68,91.64) ; J16.6 22.87,90.12 23.5,90.75 45.77,90.75 J18.2
  L3_SIG w0.356: J18.2 57.03,84.49 57.03,87.92 61.5,92.38 75.94,92.38 v2(76.68,91.64) ; v2(32.46,31.71) 32.46,32.26 33.84,33.64 33.84,43.95 34.25,44.36 v3(34.25,44.38)
  BOTTOM w0.356: J18.2 53.04,80.5 53.04,77.94 45.64,70.54 45.64,60.12 45.21,59.69 35.2,59.69 28.2,52.68 28.2,47.19 28.51,46.88 v2(28.51,45.73)
I2C_SDA_3P3V: length 101.2
  TOP w0.254: v2(77.36,95.86) U6.8 78.04,95.19 78.35,95.5
  TOP w0.356: 78.35,95.5 79.29,95.5 R78.2 79.64,95.4 81.31,95.4 ; U13.6 78.4,105.2 78.66,105.46 81.23,105.46 81.58,105.11 81.58,95.68 81.31,95.4 ; R116.2 72.82,51.44 73.48,52.1 73.48,85.64 81.71,93.87 81.71,95 81.31,95.4
  BOTTOM w0.356: v2(77.36,95.86) 77.36,96.63 67.47,106.52 53.69,106.52 51.51,108.7 51.51,110.33 J10.3
IRQ: length 158.1
  TOP w0.127: v2(32.77,54.1) 34.52,52.35 34.52,51.05 35.1,50.47 35.71,50.47 36.14,50.04 36.14,49.33 36.3,49.17 U1.A3
  TOP w0.254: 2.74,52.26 3.31,52.84 R70.2
  TOP w0.356: 2.74,52.26 2.74,25.91 4.53,24.12 14.95,24.12 21.21,17.86 21.21,17.68 21.22,17.67 R16.2 v2(20.48,17.11) ; v2(33.74,25.65) 33.74,25.66 36.81,28.73 40.26,28.73 45.07,33.55 48.4,33.55 TP1.1 U2.2
  L3_SIG w0.356: v2(20.48,17.11) 20.48,22.1 24.03,25.65 v2(33.74,25.65)
  BOTTOM w0.356: v2(32.77,54.1) 32.74,54.13 32.74,55.22 35.97,58.45 47.8,58.45 48.59,57.66 48.59,44.4 42.9,38.71 38.05,38.71 35.03,35.69 35.03,26.29 34.39,25.65 v2(33.74,25.65)
IRQ_LED: length 1.5
  TOP w0.356: R2.1 D1.1
IRQ_OUT: length 2.6
  TOP w0.356: U2.4 54.9,32.96 R2.2 R1.2
ML0N: length 22.7
  TOP w0.076: U1.F9 39.68,46.4 39.81,46.27
  TOP w0.127: 39.81,46.27 40.52,46.27 41.16,45.63 41.27,45.63 41.35,45.71 41.35,45.92 41.42,46 41.52,46 41.6,45.92 41.6,45.71 41.67,45.63 41.78,45.63 41.85,45.71 41.85,45.92 41.93,46 42.03,46 42.11,45.92 42.11,45.71 42.18,45.63 49.59,45.63 52.33,42.89 59.11,42.89 C69.1
ML0P: length 22.2
  TOP w0.076: 39.77,46 39.62,46.16 39.17,46.16 U1.F8
  TOP w0.127: 39.77,46 40.41,46 41.05,45.37 49.48,45.37 52.22,42.62 59.09,42.62 C70.1
ML1N: length 22.7
  TOP w0.076: 39.84,46.87 39.83,46.87 39.82,46.88 39.58,46.88 39.55,46.9 U1.E9
  TOP w0.127: 39.84,46.87 40.42,46.87 40.49,46.94 40.49,47.15 40.55,47.22 40.65,47.22 40.71,47.15 40.71,46.94 40.78,46.87 40.88,46.87 40.94,46.94 40.94,47.15 41.01,47.22 41.1,47.22 41.17,47.15 41.17,46.94 41.24,46.87 52.06,46.87 54.33,44.61 56.14,44.61 57.38,45.85 59.08,45.85 C67.1
ML1P: length 22.2
  TOP w0.076: 39.84,46.6 39.73,46.6 39.67,46.66 39.14,46.66 38.81,46.9 U1.E8
  TOP w0.127: C68.1 59.12,45.58 57.49,45.58 56.25,44.34 54.22,44.34 51.95,46.6 39.84,46.6
ML2N: length 22.7
  TOP w0.076: 39.67,47.92 39.65,47.9 39.3,47.9 U1.C9
  TOP w0.127: C75.1 59.1,48.87 54.09,48.87 52.78,50.19 49.81,50.19 47.62,47.99 41.43,47.99 41.36,48.06 41.36,48.18 41.3,48.25 41.2,48.25 41.13,48.18 41.13,48.06 41.07,47.99 40.97,47.99 40.91,48.06 40.91,48.18 40.84,48.25 40.74,48.25 40.68,48.18 40.68,48.06 40.61,47.99 40.52,47.99 40.45,48.06 40.45,48.18 40.38,48.25 40.29,48.25 40.22,48.18 40.22,48.06 40.15,47.99 39.81,47.99 39.75,47.92 39.67,47.92
ML2P: length 22.2
  TOP w0.076: 39.44,47.66 39.18,47.66 39.01,47.83 U1.C8
  TOP w0.127: C76.1 59.12,48.61 53.98,48.61 52.67,49.92 49.92,49.92 47.73,47.73 39.92,47.73 39.86,47.66 39.44,47.66
ML3N: length 22.7
  TOP w0.076: 39.34,48.4 U1.B9
  TOP w0.127: 39.34,48.4 39.79,48.86 39.92,48.86 39.98,48.92 39.98,49.15 40.05,49.21 40.14,49.21 40.21,49.15 40.21,48.92 40.28,48.86 40.37,48.86 40.44,48.92 40.44,49.15 40.51,49.21 40.6,49.21 40.67,49.15 40.67,48.92 40.73,48.86 45.94,48.86 48.99,51.91 59.1,51.91 C73.1
ML3P: length 22.2
  TOP w0.076: 39.47,48.16 39.12,48.16 U1.B8
  TOP w0.127: C64.1 59.1,51.64 49.1,51.64 46.05,48.59 39.9,48.59 39.47,48.16
PG: length 86.2
  TOP w0.356: U4.1 4.18,95.42 R103.1 4.17,94.64 v2(4.17,94.64) ; v2(32.54,59.15) 33.42,58.27 34.38,58.27 35.66,59.54 R88.1 36.5,61.3 37.68,62.48 40.94,62.48 42.17,63.71 42.17,68.97 40.74,70.39 R80.1
  BOTTOM w0.356: v2(4.17,94.64) 4.17,94.64 4.17,94.4 5.58,93 5.58,81.04 15.92,70.69 15.92,60.79 23.04,53.67 28.04,53.67 32.54,58.17 v2(32.54,59.15)
PG1P2: length 2.4
  TOP w0.356: U8.9 41.09,74.22 R80.2
PG1P8: length 2.2
  TOP w0.356: R88.2 35.66,63 35.65,63.01 U9.9
PG3P3: length 2.6
  TOP w0.254: U14.4 50.46,100.45 50.8,100.79 R83.1
REFCLK: length 31.9
  L3_SIG w0.356: v2(39.48,51.12) 39.48,50.54 40.26,49.76 40.26,48.87 40.72,48.41 40.72,46.08 41.02,45.77 41.02,44.68 40.72,44.37 40.72,42.89 40.24,42.41 40.24,39.4 38.18,37.34 38.18,25.68 v2(37.18,24.68)
  BOTTOM w0.356: v2(37.18,24.68) C55.1 38.09,24.7 R67.1 ; v2(39.48,51.12) 39.48,50.24 R104.1
RESET#: length 1.5
  TOP w0.356: R52.2 8.7,99.86 U3.1
RHPD: length 4.2
  TOP w0.076: U1.J8 39.04,44.66 39.04,44.37 v2(39.78,43.64)
  BOTTOM w0.356: R111.2 38,43.59 R5.1 39.73,43.59 v2(39.78,43.64)
RREFCLK: length 1.4
  TOP w0.152: U1.A7 38.43,49.03 v1(38.43,49.56)
  BOTTOM w0.356: v1(38.43,49.56) 38.43,50.13 R104.2
SS1P2: length 2.1
  TOP w0.356: C44.1 44.37,79.89 44.35,79.88 U8.15
SS1P8: length 2.3
  TOP w0.356: U9.15 39.07,68.36 39.09,68.39 C48.1
SS_TR: length 1.9
  TOP w0.254: C40.1 45.04,100.45 U14.9
TEST1: length 34.3
  TOP w0.076: U1.B3 36.3,48.41 36.06,48.65 36.06,49.11 35.92,49.25 35.92,49.83
  TOP w0.127: 35.92,49.83 35.59,50.16
  TOP w0.203: 35.59,50.16 34.98,50.16 34.54,50.6 34.49,50.6
  TOP w0.254: 34.49,50.6 34.14,50.95
  TOP w0.356: 34.14,50.95 34.14,51.89 29.53,56.5 29.53,69.88 v2(24.64,74.78) SW2.11 R59.1
TEST2: length 36.5
  TOP w0.076: 36.91,49.88 36.91,49.73 37.03,49.61 37.03,49.01 37.04,49 37.04,48.66 37.3,48.4 U1.B5
  TOP w0.127: 36.91,49.88 36.91,50.42 36.07,51.26 35.66,51.26 35.53,51.38 35.53,52.7 36.37,53.54 v2(36.75,53.54)
  TOP w0.356: R60.1 SW2.10 v2(25.91,74.68) 30.25,70.34 30.25,59.72 33.39,56.58 35.13,56.58 36.93,54.78 36.93,53.72 v2(36.75,53.54)
TSL_A0: length 4.5
  TOP w0.356: R188.2 71.25,103.5 R189.1 73.66,102.87 U13.2
TSL_INT: length 2.5
  TOP w0.356: U13.5 79.5,102.87 80.14,103.5 R191.1
N16337340: length 6.5
  TOP w0.356: v2(6.88,98.51) 6.88,98.5 U4.4 ; v2(8.28,101.78) 7.18,101.78 U3.3
  BOTTOM w0.356: v2(8.28,101.78) 8.56,101.78 8.9,101.44 8.9,100.52 v2(6.88,98.51)
N16337368: length 26.1
  TOP w0.356: SW1.3 SW1.4 8.41,81.47 3.51,86.37 C24.1 3.51,91.42 R53.2 3.48,92.49 4.79,93.8 5.74,93.8 6.23,94.29 U4.2
N16553551: length 1.5
  TOP w0.254: J4.38 R70.1
N16649721: length 2.3
  TOP w0.254: J4.37 13.48,52.87
  TOP w0.356: 13.48,52.87 R29.1
N16727318: length 1.8
  TOP w0.356: R101.1 39.32,84.91 D6.1
N16746732: length 2.7
  BOTTOM w0.203: J9.20 77.71,53.99 R112.1
N16749444: length 3.4
  TOP w0.203: R116.1 71.06,51.5 J6.4
N16749448: length 3.6
  TOP w0.203: J6.2 70.41,52 R117.1
N16759353: length 11.5
  TOP w0.254: U14.13 46.24,98.18 v2(45.29,97.23)
  BOTTOM w0.356: v2(45.29,97.23) 45.29,95.61 ; 45.29,95.61 45.29,92.86 44.5,92.08 J14.2 ; 45.29,95.61 45.24,95.55 R86.2
N16817438: length 16.7
  TOP w0.356: R16.1 21.22,15.26 22.58,13.89 29.79,13.89 31.42,12.27 31.42,9.45 J1.10

## Copper pours and planes (outline as drawn)
9V_DIODE on TOP (solid shape): 26.04,103.5 28.57,103.5 28.57,101.6 26.67,101.6 24.77,99.69 17.78,99.69 16.51,100.97 16.51,104.78 17.14,105.41 24.13,105.41
GND on TOP (solid shape): 31.75,100.58 30.48,100.58 30.48,102.23 31.75,102.23
GND on TOP (solid shape): 48.45,98.87 46.8,98.87 46.8,100.52 48.45,100.52
GND on TOP (solid shape): 45.01,102.82 45.01,102.59 44.75,102.34 44.75,101.8 44.17,101.8 44.17,102.41 43.97,102.62 43.97,102.79 44.15,102.97 44.86,102.97
GND on TOP (solid shape): 48.51,101.6 48.51,100.71 48.44,100.63 48.44,99.97 48.29,99.82 46.91,99.82 46.86,99.87 46.86,100.66 46.76,100.76 46.76,101.6 46.79,101.63 48.49,101.63
GND on TOP (solid shape): 48.51,98.81 48.51,97.51 48.46,97.46 48.46,92.76 48.13,92.43 45.01,92.43 42.62,94.82 42.62,95.48 42.32,95.78 40.11,95.78 39.95,95.94 39.95,97 40.44,97.49 44.12,97.49 44.81,96.8 47.47,96.8 47.73,97.05 47.73,98.88 48.08,99.24
GND on BOTTOM: 32.64,65.53 38.48,65.53 46.48,73.53 46.48,77.34 43.94,79.88 38.86,79.88 31.75,72.77 31.75,66.42
GND on L2_GND: 1.31,1.41 92.71,1.41 92.71,115.38 1.31,115.38
GND on L3_SIG: 1.31,1.41 92.71,1.41 92.71,115.38 1.31,115.38 ; 3 cut-outs
GND on L5_GND: 1.3,1.48 1.3,115.47 92.71,115.47 92.71,1.48
VCC on TOP (solid shape): 45.85,53.67 45.95,53.57 46.66,53.57 47.32,52.91 47.32,51.66 46.94,51.28 45.75,51.28 45.29,51.74 45.29,54.18 45.34,54.23 45.85,54.23
VCC on L4_PWR: 34.92,42.55 48.26,42.55 48.26,53.98 40.39,53.98 40.39,48.51 36.96,48.51 36.96,47.37 41.15,47.37 41.15,44.45 38.1,44.45 38.1,43.81 34.92,43.81
VCCA on TOP (solid shape): 25.43,53.24 25.43,52.5 26.09,51.84 26.09,50.77 25.83,50.52 24.71,50.52 24.41,50.83 24.41,52.17 24.87,52.63 24.87,53.24 24.92,53.29 25.37,53.29
VCCA on L4_PWR: 22.23,44.07 37.47,44.07 37.47,45.09 40.51,45.09 40.51,46.74 36.32,46.74 36.32,49.15 39.75,49.15 39.75,53.98 22.23,53.98
BOARD_1P2V on TOP (solid shape): 45.24,59.89 45.85,59.28 45.85,55.04 45.75,54.94 45.29,54.94 45.29,55.6 44.42,56.46 44.42,60.96 45.24,60.96
BOARD_1P2V on TOP (solid shape): 25.83,56.13 25.83,55.09 25.43,54.69 25.43,54.08 25.35,54 24.84,54 24.84,54.76 24.41,55.19 24.41,56.18 24.56,56.34 25.63,56.34
BOARD_1P2V on BOTTOM: 30.56,78.44 31.75,79.63 36.8,79.63 37.35,80.18 41.16,80.18 42.32,81.33 42.32,83.31 40.61,85.01 29.16,85.01 27.23,83.08 27.23,66.29 24.74,63.8 23.04,63.8 22.25,63.02 22.25,57.23 23.83,55.65 27.2,55.65 30.56,59 30.56,61.7 40.44,61.7 42.11,60.02 44.98,60.02 45.26,60.3 45.26,62.48 42.77,64.97 30.56,64.97
BOARD_1P8V on L4_PWR: 1.42,1.48 1.42,93.77 1.39,93.81 1.39,114.94 26.04,114.94 26.04,77.47 36.2,77.47 36.2,66.52 29.21,66.52 29.21,60.33 83.82,60.33 83.82,86.36 73.03,86.36 73.03,95.25 74.93,95.25 74.93,90.17 92.71,90.17 92.71,1.41 25.07,1.41 25.07,1.48 ; 3 cut-outs
BOARD_3P3V on TOP (solid shape): 60.76,95.05 60.76,93.34 60.05,92.63 50.14,92.63 49.83,92.94 49.83,96.44 49.99,96.6 51.16,96.6 51.44,96.88 58.93,96.88
BOARD_3P3V on L4_PWR: 83.19,60.96 29.84,60.96 29.84,66.04 36.83,66.04 36.83,78.11 26.67,78.11 26.67,97.41 56.52,97.41 56.52,114.94 92.71,114.94 92.71,90.81 75.56,90.81 75.56,95.89 72.39,95.89 72.39,85.72 83.19,85.72 ; 1 cut-out
BOARD_9V on TOP (solid shape): 42.32,100.18 44.32,100.18 44.42,100.08 46.38,100.08 46.51,99.95 46.51,98.88 46.46,98.83 45.59,98.83 45.42,98.65 40.34,98.65 39.5,99.49 36.25,99.49 35.81,99.92 35.81,100.91 36.07,101.17 41.33,101.17
BOARD_9V on L4_PWR: 26.67,98.04 26.67,115.23 55.88,115.23 55.88,98.04
DPTX_GND on TOP: 80.39,40.39 92.08,40.39 92.08,42.04 87.5,46.61 87.5,52.2 91.82,56.52 91.82,58.93 90.3,60.45 90.3,61.85 89.79,61.85 89.79,60.83 89.28,60.33 83.44,60.33 82.8,60.96 82.8,61.85 82.42,61.85 82.42,60.58 81.15,59.31 81.15,56.26 85.09,52.32 85.09,46.61 80.39,41.91
EDP_BL_PWR on TOP (solid shape): 70.26,39.17 70.26,38.79 69.37,37.9 66.65,37.9 66.65,40.08 66.67,40.11 69.32,40.11
LED9V on TOP (solid shape): 31.75,104.14 30.48,104.14 30.48,106.68 31.75,106.68
Net_75 on TOP (solid shape): 82.62,34.15 82.79,34.03 82.91,33.85 82.95,33.64 82.9,33.41 82.79,33.25 82.6,33.12 82.4,33.09 82.18,33.13 82.01,33.24 81.88,33.43 81.84,33.64 81.89,33.87 81.99,34.02 82.19,34.16 82.4,34.19
Net_76 on TOP (solid shape): 80.29,35.75 80.29,33.86 80.43,33.16 80.66,32.84 81.02,32.68 81.59,32.71 81.46,31.7 80.93,31.7 80.8,30.85 81.32,30.85 81.07,28.98 81.07,28.82 81.14,28.64 81.33,28.4 81.48,28.3 81.7,28.2 81.99,28.12 82.41,28.08 82.77,28.12 82.91,28.19 82.95,28.25 82.95,28.78 82.79,28.8 82.58,28.84 82.51,28.9 82.47,29.02 82.75,30.85 83.29,30.85 83.43,31.69 82.91,31.71 83.08,32.78 83.31,32.86 83.97,32.91 84.67,32.79 85.03,32.55 85.6,32.45 85.58,31.27 85.75,30.85 85.89,30.27 85.96,29.35 85.89,28.29 85.79,27.98 85.65,27.82 85.38,27.7 84.58,27.5 84,27.22 82.85,26.78 82.15,26.23 81.6,25.59 81.37,24.81 81.41,24.27 81.49,23.86 81.69,23.27 81.69,23.1 81.25,23.2 80.78,23.25 80.38,23.55 80.17,23.62 79.96,23.98 79.18,25.6 78.86,26.23 78.4,27.34 78.06,27.83 77.81,27.97 77.44,27.96 77.01,27.72 76.86,27.59 76.55,27.52 76.33,27.58 76.06,27.88 75.65,28.36 75.32,28.89 74.93,29.35 74.52,29.77 74.04,29.96 73.84,30.13 73.77,30.31 73.66,30.49 77.44,30.49 77.44,35.76
Net_77 on TOP (solid shape): 82.29,29.27 81.32,29.26 81.8,32.56 82.77,32.57
PWRIN_SW on TOP (solid shape): 29.21,108.58 28.57,107.95 28.57,106.05 27.3,106.05 27.3,108.58 26.04,109.86 26.04,113.03 26.67,113.67 29.21,113.67
SWOUT on TOP (solid shape): 54.2,100.03 54.2,98.91 54,98.7 50.01,98.7 49.89,98.83 48.74,98.83 48.72,98.86 48.72,100.03 48.77,100.08 50.83,100.08 51,100.25 53.98,100.25

## Text on the board
Ref Des/Silkscreen Bottom: DPTX | 1 | 20
TOP: SN65DSI86/96 EVM | REV3 | 6570803 | TEXAS INSTRUMENTS
Board Geometry/Soldermask Top: SN65DSI86/96 EVM | REV3 | 6570803 | TEXAS INSTRUMENTS
Ref Des/Silkscreen Top: RESETN | GND | 5-17V | VCCA | ON | BRD_1P2V | OFF | REG3VEN | VCCIO | VCC | IRQ | BRD_1P8V | 3.3V | I2C | EDPTX_CNTR | DSI_ACLKP | DSI_ACLKN | GPIO1 | CENTER PIN POSITIVE | OUTER SHIELD IS GND | GPIO2 | DSI_A3P | GPIO3 | DSI_A3N | GPIO4 | ADDR | DSI_A2P | I2C_SDA | TEST1 | DSI_A2N | I2C_SCL | TEST2 | I2C_3V3EN | HPD | DSI_A1P | DSI_A1N | BL_PWR | DSI_A0P | SDA | REFCLK | SCL | DSI_A0N | CDC_S0 | SCL_3P3V | CDC_S1 | SDA_3P3V | CDC_SDA ON | CDC_S2_SCL | CDC_SCL_ON | LCD_VCC | 2 | 1 | 10 | 9 | DSI96 | DSI86
PAGE_OUTLINE: GENERAL NOTES. UNLESS OTHERWISE SPECIFIED | 1.  ALL FABRICATION ITEMS MUST MEET OR EXCEED BEST | INDUSTRY PRACTICE : IPC-A-600C (Commercial std.) | 2.  LAMINATE MATERIAL  :  FR4 POLYCLAD 370 or EQUIVALENT | 3.  COPPER WEIGHT  : 1oz START INTERNAL, 1/2oz START EXTERNAL | 4.  FINISHED BOARD THICKNESS :  .062  +/- 10% | 5.  MAXIMUM WARP AND TWIST TO BE :  .005 INCH PER INCH | 6.  MINIMUM COPPER WALL THICKNESS OF PLATED-THRU | HOLES TO BE .001 INCH. THERE MUST BE 1 MIL OR GREATER PLATING ON | EACH SIDE OF THE BARREL WHEN VIEWED IN THE CROSS SECTION | 7.  MINIMUM ANNULAR RING OF PLATED-THRU HOLES | TO BE .002 INCH | 8.  MINIMUM ALLOWABLE LINE REDUCTION TO BE | 20% OR .002 WHICHEVER IS GREATER | 9.  0.003 AND 0.005 SIGNAL LINES ON LAYER 1 & 3 & 6 TO BE | IMPEDANCE CONTROLLED 100 OHMS DIFFERENTIAL +/- 10% | 10. 0.014 SIGNAL LINES ON LAYER 1 & 3 & 6 TO BE | IMPEDANCE CONTROLLED 50 OHMS +/- 10% | 11. DIELECTRIC CONSTANTS ARE         CORE : 4.1 | PREPREG : 4.1 | 12. Vias in SMT device pads to be filled with Non Conductive Epoxy. | ANY VOID IN THE FILL MATERIAL MUST NOT BE GREATER THAN 25% | OF THE FINISHED HOLE DIAMETER | 13. A CROSS SECTION MOUNT AND DIGITAL PHOTOS OF VIAS TO BE PROVIDED | 14. USE THE (DRPP) DUTCH REVERSE PLATING PROCESS | PROCESS NOTES | 1. CIRCUITRY ON OUTER LAYERS TO BE PLATED WITH : NICKEL GOLD | 2. SOLDERMASK BOTH SIDES PER ARTWORK  :  RED LPI | 3. SILKSCREEN BOTH SIDES PER ARTWORK  :  COLOR = WHITE | TOP SIDE VIEW
DIMENSION: 20 mil | 8 mil | 8mil | 1 | 2 | 3 | 4 | 5 | 6 | TOP | L2_GND | L3_SIG | L4_PWR | L5_GND | BOTTOM | 17. SOLDERMASK ARTWORK HAS ZERO (0) OVERSIZED PADS. | 16. BOARD MUST BE ELECTRICALLY TESTED USING | 15. ALL DIMENSIONS ARE IN INCHES UNLESS | SUPPLIED IPC-D-356 NETLIST. | FABRICATION VENDOR IS ALLOWED TO ADJUST THE COMPONENT | SOLDERMASK PADS TO MEET THEIR TOOLING REQUIREMENTS | WHILE MAINTAINING WEBBING BETWEEN ADJACENT PADS. | OTHERWISE NOTED.  ALL BOARD | OUTLINE DIMENSION TOLERANCES ARE +/- .010". | 0
COMPVAL_TYPE_BOTTOM: FIGURE | SIZE | 5.0 | 6.0 | 8.0 | 12.0 | 16.0 | 38.0 | 40.0 | 43.0 | 52.0 | 120.0 | 140.0 | 160.0 | 33.465 | 55.118 | 63.386 | 66.929x23.618 | 86.61x23.618 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILS | TOLERANCE | +3.0/-5.0 | +3.0/-6.0 | +3.0/-8.0 | +3.0/-12.0 | +3.0/-3.0 | +2.0/-2.0 | PLATED | NON-PLATED | QTY | 44 | 3 | 359 | 4 | 2 | 69 | 6 | 8 | 1 | 7
